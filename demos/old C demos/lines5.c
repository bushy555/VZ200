
#define SCRSIZE     2048
char scr[128*64];
/* char scr2[128*64*2]; */
char *mem;
main(argc, argv)
int argc;
int *argv;


{	int a[5],b[5],c[5],d[5],e[5],f[5],g[5],h[5],i[5],j[5],k[5],l[5];
	int a1[5],b1[5],c1[5],d1[5],e1[5],f1[5],g1[5],h1[5],i1[5],j1[5],k1[5],l1[5];

	
	int y[7];
	int z;

    	mode(1);
	for (z=0;z<5;z++) {
	   a[z]=30;
	   c[z]=42;
	   e[z]=56;
           g[z]=78;
   	   i[z]=82;
	   k[z]=100;
	};

	y[0] = 15; /* Y param of first box */
	y[1] = 29;
	y[2] = 33;
	y[3] = 48;
	y[4] = 53; /* Y param of second box */
	y[5] = 60;
	
	for (z=0;z<5;z++) {
	   b[z]=y[0];
	   d[z]=y[1];
	   f[z]=y[2];
           h[z]=y[3];
           j[z]=y[4];
           l[z]=y[5];
         
	   y[0]=y[0]-3;
	   y[1]=y[1]-3;
	   y[2]=y[2]-3;
	   y[3]=y[3]-3;
	   y[4]=y[4]-3;
	   y[5]=y[5]-3;
	   y[6]=y[6]-3;
	   y[7]=y[7]-3;
	};

	for (z=0;z<5;z++) {
	a1[z]=1;
	b1[z]=1;
	c1[z]=1;
	d1[z]=1;
	e1[z]=1;
	f1[z]=1;
	g1[z]=1;
	h1[z]=1;
	i1[z]=1;
	j1[z]=1;
	k1[z]=1;
	l1[z]=1;
	};
	setbase(scr); 
	asm("di\n");
	while(!(z==2)){
	a[0]=a[0]+a1[0];
	b[0]=b[0]+b1[0];
	c[0]=c[0]+c1[0];
	d[0]=d[0]+d1[0];
	e[0]=e[0]+e1[0];
	f[0]=f[0]+f1[0];
	g[0]=g[0]+g1[0];
	h[0]=h[0]+h1[0];
	i[0]=i[0]+i1[0];
	j[0]=j[0]+j1[0];
	k[0]=k[0]+k1[0];
	l[0]=l[0]+l1[0];

	a[1]=a[1]+a1[1];
	b[1]=b[1]+b1[1];
	c[1]=c[1]+c1[1];
	d[1]=d[1]+d1[1];
	e[1]=e[1]+e1[1];
	f[1]=f[1]+f1[1];
	g[1]=g[1]+g1[1];
	h[1]=h[1]+h1[1];
	i[1]=i[1]+i1[1];
	j[1]=j[1]+j1[1];
	k[1]=k[1]+k1[1];
	l[1]=l[1]+l1[1];

	a[2]=a[2]+a1[2];
	b[2]=b[2]+b1[2];
	c[2]=c[2]+c1[2];
	d[2]=d[2]+d1[2];
	e[2]=e[2]+e1[2];
	f[2]=f[2]+f1[2];
	g[2]=g[2]+g1[2];
	h[2]=h[2]+h1[2];
	i[2]=i[2]+i1[2];
	j[2]=j[2]+j1[2];
	k[2]=k[2]+k1[2];
	l[2]=l[2]+l1[2];
	
	line(a[0],b[0], c[0],d[0], 1);
	line(c[0],d[0], e[0],f[0], 1);
	line(e[0],f[0], g[0],h[0], 1);
	line(g[0],h[0], i[0],j[0], 1);
	line(i[0],j[0], k[0],l[0], 1);

	line(a[1],b[1], c[1],d[1], 2);
	line(c[1],d[1], e[1],f[1], 2);
	line(e[1],f[1], g[1],h[1], 2);
	line(g[1],h[1], i[1],j[1], 2);
	line(i[1],j[1], k[1],l[1], 2);

	line(a[2],b[2], c[2],d[2], 3);
	line(c[2],d[2], e[2],f[2], 3);
	line(e[2],f[2], g[2],h[2], 3);
	line(g[2],h[2], i[2],j[2], 3);
	line(i[2],j[2], k[2],l[2], 3);

	soundcopy(0x7000,scr,SCRSIZE,0,0);

	memset(scr, 0, 2048); 

	if (a[0]<1)    a1[0]=1;
	if (a[0]>126)  a1[0]=-1;
	if (b[0]<1)    b1[0]=1;
	if (b[0]>62)   b1[0]=-1;
	if (c[0]<1)    c1[0]=1;
	if (c[0]>126)  c1[0]=-1;
	if (d[0]<1)    d1[0]=1;
	if (d[0]>62)   d1[0]=-1;
	if (e[0]<1)    e1[0]=1;
	if (e[0]>126)  e1[0]=-1;
	if (f[0]<1)    f1[0]=1;
	if (f[0]>62)   f1[0]=-1;
	if (g[0]<1)    g1[0]=1;
	if (g[0]>126)  g1[0]=-1;
	if (h[0]<1)    h1[0]=1;
	if (h[0]>62)   h1[0]=-1;
	if (i[0]<1)    i1[0]=1;
	if (i[0]>126)  i1[0]=-1;
	if (j[0]<1)    j1[0]=1;
	if (j[0]>62)   j1[0]=-1;
	if (k[0]<1)    k1[0]=1;
	if (k[0]>126)  k1[0]=-1;
	if (l[0]<1)    l1[0]=1;
	if (l[0]>62)   l1[0]=-1;

	if (a[1]<1)    a1[1]=1;
	if (a[1]>126)  a1[1]=-1;
	if (b[1]<1)    b1[1]=1;
	if (b[1]>62)   b1[1]=-1;
	if (c[1]<1)    c1[1]=1;
	if (c[1]>126)  c1[1]=-1;
	if (d[1]<1)    d1[1]=1;
	if (d[1]>62)   d1[1]=-1;
	if (e[1]<1)    e1[1]=1;
	if (e[1]>126)  e1[1]=-1;
	if (f[1]<1)    f1[1]=1;
	if (f[1]>62)   f1[1]=-1;
	if (g[1]<1)    g1[1]=1;
	if (g[1]>126)  g1[1]=-1;
	if (h[1]<1)    h1[1]=1;
	if (h[1]>62)   h1[1]=-1;
	if (i[1]<1)    i1[1]=1;
	if (i[1]>126)  i1[1]=-1;
	if (j[1]<1)    j1[1]=1;
	if (j[1]>62)   j1[1]=-1;
	if (k[1]<1)    k1[1]=1;
	if (k[1]>126)  k1[1]=-1;
	if (l[1]<1)    l1[1]=1;
	if (l[1]>62)   l1[1]=-1;

	if (a[2]<1)    a1[2]=1;
	if (a[2]>126)  a1[2]=-1;
	if (b[2]<1)    b1[2]=1;
	if (b[2]>62)   b1[2]=-1;
	if (c[2]<1)    c1[2]=1;
	if (c[2]>126)  c1[2]=-1;
	if (d[2]<1)    d1[2]=1;
	if (d[2]>62)   d1[2]=-1;
	if (e[2]<1)    e1[2]=1;
	if (e[2]>126)  e1[2]=-1;
	if (f[2]<1)    f1[2]=1;
	if (f[2]>62)   f1[2]=-1;
	if (g[2]<1)    g1[2]=1;
	if (g[2]>126)  g1[2]=-1;
	if (h[2]<1)    h1[2]=1;
	if (h[2]>62)   h1[2]=-1;
	if (i[2]<1)    i1[2]=1;
	if (i[2]>126)  i1[2]=-1;
	if (j[2]<1)    j1[2]=1;
	if (j[2]>62)   j1[2]=-1;
	if (k[2]<1)    k1[2]=1;
	if (k[2]>126)  k1[2]=-1;
	if (l[2]<1)    l1[2]=1;
	if (l[2]>62)   l1[2]=-1;

	};
    return 0;
}
