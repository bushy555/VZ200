
#define SCRSIZE     2048
char scr[128*64];
/* char scr2[128*64*2]; */
char *mem;
main(argc, argv)
int argc;
int *argv;


{	int a[5],b[5],c[5],d[5],e[5],f[5],g[5],h[5],m[5],n[5],o[5],p[5],q[5],r[5],s[5],t[5];
	int a1[5],b1[5],c1[5],d1[5],e1[5],f1[5],g1[5],h1[5],m1[5],n1[5],o1[5],p1[5],q1[5],r1[5],s1[5];
	int t1[5];
	
	int y[7];
	int z;

    	mode(1);
	for (z=0;z<5;z++) {
	   a[z]=30;
	   c[z]=82;
	   e[z]=76;
           g[z]=28;
   	   m[z]=12;
	   o[z]=100;
	   q[z]=120;
           s[z]=8;
	};

	y[0] = 19; /* Y param of first box */
	y[1] = 31;
	y[2] = 46;
	y[3] = 31;

	y[4] = 13; /* Y param of second box */
	y[5] = 15;
	y[6] = 62;
	y[7] = 57;
	
	for (z=0;z<5;z++) {
	   b[z]=y[0];
	   d[z]=y[1];
	   f[z]=y[2];
           h[z]=y[3];
           n[z]=y[4];
           p[z]=y[5];
           r[z]=y[6];
           t[z]=y[7];
         
	   y[0]=y[0]-3;
	   y[1]=y[1]-3;
	   y[2]=y[2]-3;
	   y[3]=y[3]-3;
	   y[4]=y[4]-3;
	   y[5]=y[5]-3;
	   y[6]=y[6]-3;
	   y[7]=y[7]-3;
	};

	for (z=0;z<5;z++) {
	a1[z]=1;
	b1[z]=1;
	c1[z]=1;
	d1[z]=1;
	e1[z]=1;
	f1[z]=1;
	g1[z]=1;
	h1[z]=1;
	m1[z]=1;
	n1[z]=1;
	o1[z]=1;
	p1[z]=1;
	q1[z]=1;
	r1[z]=1;
	s1[z]=1;
	t1[z]=1;
	};
	setbase(scr); 
	asm("di\n");
	while(!(z==2)){
	a[0]=a[0]+a1[0];
	b[0]=b[0]+b1[0];
	c[0]=c[0]+c1[0];
	d[0]=d[0]+d1[0];
	e[0]=e[0]+e1[0];
	f[0]=f[0]+f1[0];
	g[0]=g[0]+g1[0];
	h[0]=h[0]+h1[0];
	a[1]=a[1]+a1[1];
	b[1]=b[1]+b1[1];
	c[1]=c[1]+c1[1];
	d[1]=d[1]+d1[1];
	e[1]=e[1]+e1[1];
	f[1]=f[1]+f1[1];
	g[1]=g[1]+g1[1];
	h[1]=h[1]+h1[1];
	a[2]=a[2]+a1[2];
	b[2]=b[2]+b1[2];
	c[2]=c[2]+c1[2];
	d[2]=d[2]+d1[2];
	e[2]=e[2]+e1[2];
	f[2]=f[2]+f1[2];
	g[2]=g[2]+g1[2];
	h[2]=h[2]+h1[2];
	

	m[0]=m[0]+m1[0];
	n[0]=n[0]+n1[0];
	o[0]=o[0]+o1[0];
	p[0]=p[0]+p1[0];
	q[0]=q[0]+q1[0];
	r[0]=r[0]+r1[0];
	s[0]=s[0]+s1[0];
	t[0]=t[0]+t1[0];
	m[1]=m[1]+m1[1];
	n[1]=n[1]+n1[1];
	o[1]=o[1]+o1[1];
	p[1]=p[1]+p1[1];
	q[1]=q[1]+q1[1];
	r[1]=r[1]+r1[1];
	s[1]=s[1]+s1[1];
	t[1]=t[1]+t1[1];
	m[2]=m[2]+m1[2];
	n[2]=n[2]+n1[2];
	o[2]=o[2]+o1[2];
	p[2]=p[2]+p1[2];
	q[2]=q[2]+q1[2];
	r[2]=r[2]+r1[2];
	s[2]=s[2]+s1[2];
	t[2]=t[2]+t1[2];

	line(a[0],b[0], c[0],d[0], 2);
	line(c[0],d[0], e[0],f[0], 2);
	line(e[0],f[0], g[0],h[0], 2);
	line(g[0],h[0], a[0],b[0], 2);
	line(a[1],b[1], c[1],d[1], 2);
	line(c[1],d[1], e[1],f[1], 2);
	line(e[1],f[1], g[1],h[1], 2);
	line(g[1],h[1], a[1],b[1], 2);
	line(a[2],b[2], c[2],d[2], 2);
	line(c[2],d[2], e[2],f[2], 2);
	line(e[2],f[2], g[2],h[2], 2);
	line(g[2],h[2], a[2],b[2], 2);

	line(m[0],n[0], o[0],p[0], 3);
	line(o[0],p[0], q[0],r[0], 3);
	line(q[0],r[0], s[0],t[0], 3);
	line(s[0],t[0], m[0],n[0], 3);
	line(m[1],n[1], o[1],p[1], 3);
	line(o[1],p[1], q[1],r[1], 3);
	line(q[1],r[1], s[1],t[1], 3);
	line(s[1],t[1], m[1],n[1], 3);
	line(m[2],n[2], o[2],p[2], 3);
	line(o[2],p[2], q[2],r[2], 3);
	line(q[2],r[2], s[2],t[2], 3);
	line(s[2],t[2], m[2],n[2], 3);

	soundcopy(0x7000,scr,SCRSIZE,0,0);

	memset(scr, 0, 2048); 

	if (a[0]<1)    a1[0]=2;
	if (a[0]>126)  a1[0]=-2;
	if (b[0]<1)    b1[0]=1;
	if (b[0]>62)   b1[0]=-1;
	if (c[0]<1)    c1[0]=1;
	if (c[0]>126)  c1[0]=-1;
	if (d[0]<1)    d1[0]=1;
	if (d[0]>62)   d1[0]=-1;
	if (e[0]<1)    e1[0]=1;
	if (e[0]>126)  e1[0]=-1;
	if (f[0]<1)    f1[0]=1;
	if (f[0]>62)   f1[0]=-1;
	if (g[0]<1)    g1[0]=1;
	if (g[0]>126)  g1[0]=-1;
	if (h[0]<1)    h1[0]=1;
	if (h[0]>62)   h1[0]=-1;
	if (a[1]<1)    a1[1]=2;
	if (a[1]>126)  a1[1]=-2;
	if (b[1]<1)    b1[1]=1;
	if (b[1]>62)   b1[1]=-1;
	if (c[1]<1)    c1[1]=1;
	if (c[1]>126)  c1[1]=-1;
	if (d[1]<1)    d1[1]=1;
	if (d[1]>62)   d1[1]=-1;
	if (e[1]<1)    e1[1]=1;
	if (e[1]>126)  e1[1]=-1;
	if (f[1]<1)    f1[1]=1;
	if (f[1]>62)   f1[1]=-1;
	if (g[1]<1)    g1[1]=1;
	if (g[1]>126)  g1[1]=-1;
	if (h[1]<1)    h1[1]=1;
	if (h[1]>62)   h1[1]=-1;
	if (a[2]<1)    a1[2]=2;
	if (a[2]>126)  a1[2]=-2;
	if (b[2]<1)    b1[2]=1;
	if (b[2]>62)   b1[2]=-1;
	if (c[2]<1)    c1[2]=1;
	if (c[2]>126)  c1[2]=-1;
	if (d[2]<1)    d1[2]=1;
	if (d[2]>62)   d1[2]=-1;
	if (e[2]<1)    e1[2]=1;
	if (e[2]>126)  e1[2]=-1;
	if (f[2]<1)    f1[2]=1;
	if (f[2]>62)   f1[2]=-1;
	if (g[2]<1)    g1[2]=1;
	if (g[2]>126)  g1[2]=-1;
	if (h[2]<1)    h1[2]=1;
	if (h[2]>62)   h1[2]=-1;


	if (m[0]<1)    m1[0]=1;
	if (m[0]>126)  m1[0]=-1;
	if (n[0]<1)    n1[0]=1;
	if (n[0]>62)   n1[0]=-1;
	if (o[0]<1)    o1[0]=1;
	if (o[0]>126)  o1[0]=-1;
	if (p[0]<1)    p1[0]=1;
	if (p[0]>62)   p1[0]=-1;
	if (q[0]<1)    q1[0]=1;
	if (q[0]>126)  q1[0]=-1;
	if (r[0]<1)    r1[0]=1;
	if (r[0]>62)   r1[0]=-1;
	if (s[0]<1)    s1[0]=1;
	if (s[0]>126)  s1[0]=-1;
	if (t[0]<1)    t1[0]=1;
	if (t[0]>62)   t1[0]=-1;
	if (m[1]<1)    m1[1]=1;
	if (m[1]>126)  m1[1]=-1;
	if (n[1]==1)   n1[1]=1;
	if (n[1]>62)   n1[1]=-1;
	if (o[1]<1)    o1[1]=1;
	if (o[1]>126)  o1[1]=-1;
	if (p[1]<1)    p1[1]=1;
	if (p[1]>62)   p1[1]=-1;
	if (q[1]<1)    q1[1]=1;
	if (q[1]>126)  q1[1]=-1;
	if (r[1]<1)    r1[1]=1;
	if (r[1]>62)   r1[1]=-1;
	if (s[1]<1)    s1[1]=1;
	if (s[1]>126)  s1[1]=-1;
	if (t[1]<1)    t1[1]=1;
	if (t[1]>62)   t1[1]=-1;
	if (m[2]<1)    m1[2]=1;
	if (m[2]>126)  m1[2]=-1;
	if (n[2]<1)    n1[2]=1;
	if (n[2]>62)   n1[2]=-1;
	if (o[2]<1)    o1[2]=1;
	if (o[2]>126)  o1[2]=-1;
	if (p[2]<1)    p1[2]=1;
	if (p[2]>62)   p1[2]=-1;
	if (q[2]<1)    q1[2]=1;
	if (q[2]>126)  q1[2]=-1;
	if (r[2]<1)    r1[2]=1;
	if (r[2]>62)   r1[2]=-1;
	if (s[2]<1)    s1[2]=1;
	if (s[2]>126)  s1[2]=-1;
	if (t[2]<1)    t1[2]=1;
	if (t[2]>62)   t1[2]=-1;


	};
    return 0;
}
